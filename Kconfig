## Kconfig
```kconfig
rsource "${SdkRootDirPath}/Kconfig.mcuxpresso"
orsource "${board}_${core_id}/Kconfig.trace"
```
